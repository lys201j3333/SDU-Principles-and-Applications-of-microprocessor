ORG 0000H
AJMP START
ORG 0030H

START:
	MOV SP,#60H
	
LOOP:
		LCALL START1
		LCALL DL10S
		LCALL START2
		LCALL DL2S
		LCALL START3
		LCALL DL10S
		LCALL START4
		LCALL DL2S
		SJMP LOOP

START1:
	MOV A,#0F3H
	MOV DPTR,#U4
	MOVX @DPTR,A
	MOV A,#0CH
	MOV DPTR,#U5
	MOVX @DPTR,A
	RET

START2:
	MOV A,#0C3H
	MOV DPTR,#U4
	MOVX @DPTR,A
	MOV A,#0FH
	MOV DPTR,#U5
	MOVX @DPTR,A
	RET

START3:
	MOV A,#0FCH
	MOV DPTR,#U4
	MOVX @DPTR,A
	MOV A,#03H
	MOV DPTR,#U5
	MOVX @DPTR,A
	RET

START4:
	MOV A,#3CH
	MOV DPTR,#U4
	MOVX @DPTR,A
	MOV A,#0FH
	MOV DPTR,#U5
	MOVX @DPTR,A
	RET

DL10S:
	MOV R1,#5
	AA1:LCALL DL2S
	DJNZ R1,AA1
	RET

DL2S:	MOV R7,#20
DL2:	MOV R6,#200
DL1:	MOV R5,#250
	DJNZ R5,$
	DJNZ R6,DL1
	DJNZ R7,DL2
	RET
U4 EQU 0FE00H
U5 EQU 0FD00H
	END