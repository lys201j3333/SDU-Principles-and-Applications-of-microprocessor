ORG 0000H
AJMP MAIN
ORG 0100H
MAIN:
MOV SP,#62H
MOV A,#0H
MOV R1,#30H
;换成十进制的31
MOV R7,#20H
MOV DPTR,#TABLE
;疑惑：这R4干嘛的
MOV R4,#1FH
LOOP1:
;MOVC是查表指令
MOVC A,@A+DPTR
MOV @R1,A
INC R1
INC DPTR
MOV A,#0H
;输入32个数
DJNZ R7,LOOP1
LOOP2: 
;清除借位标志位
CLR C
MOV A,#1FH
SUBB A,R4
ADD A,#30H
;令R1从该循环第一个数开始计算
MOV R1,A
MOV A,R4
;使R2为计算次数
MOV R2,A
MOV A,R1
;设置该循环初始值
MOV R0,A
LOOP3:
CLR C
MOV A,@R1
;R3中存入R1所指数据
MOV R3,A
MOV A,R0 
;比较R0与R1的大小
SUBB A,R1
;执行流程图第一步
JNZ X
CLR C
INC R1
X:
MOV A,@R0
;比较R1与R0+1的大小
SUBB A,@R1
JC LOOP4
MOV A,R0
INC A
SUBB A,R1
JNZ Y
MOV A,R3
XCH A,@R1
MOV @R0,A
SJMP LOOP4
Y:
MOV A,R3
XCH A,@R0
MOV @R1,A
LOOP4:
INC R1
;持续循环直至结束
DJNZ R2,LOOP3
INC R0
;持续循环直至结束
DJNZ R4,LOOP2
SJMP $
ORG 0030H
TABLE: DB 11,3,9,2,17,4,11,6
DB 5,20,100,64,21,14,79,35  
DB 92,7,91,23,65,16,13,18
DB 18,73,65,101,27,19,62,69
END