# Keil uVision project 实验3.1.1_proj.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 实验3.1.1_proj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: basicIO.asm STARTUP.A51
