DATAS SEGMENT
   BUF1 DB 10,13,'PLEASE INPUT SCORES:','$'
   SCORE6 DB 10,13,'SCORE6:','$'
   SCORE7 DB 10,13,'SCORE7:','$'
   SCORE8 DB 10,13,'SCORE8:','$'
   SCORE9 DB 10,13,'SCORE9:','$'
   SCORE10 DB 10,13,'SCORE10:','$'
   SCOREOUT DB 10,13,'OSOCRE:','$'
   SSCORE6 DB 30H
   SSCORE7 DB 30H
   SSCORE8 DB 30H
   SSCORE9 DB 30H
   SSCORE10 DB 30H
   OUTSCORE DB 30H
DATAS ENDS
STACKS SEGMENT
   DB 300 DUP(0)
STACKS ENDS
CODES SEGMENT
   ASSUME CS:CODES,DS:DATAS,SS:STACKS 
START:
   MOV AX,DATAS
   MOV DS,AX
   MOV AH,9

   LEA DX,BUF1
   INT 21H

   MOV CX,10 
INPUT: MOV AH,1
   INT 21H

   CALL COMPARE

   INT 21H

   MOV AH,2
   MOV DL,32
   INT 21H  

   LOOP INPUT 
   CALL OUTPUT
   MOV AH,4CH
   INT 21H  

COMPARE PROC
   PUSH AX

   CMP AL,31H 
   JZ S10

   CMP AL,36H    
   JZ S6
   CMP AL,37H
   JZ S7 
   CMP AL,38H  
   JZ S8    
   CMP AL,39H    
   JZ S9    
   JMP S0 


S0:
   ADD [OUTSCORE],1 
   JMP exit
S6:
   ADD [SSCORE6],1  
   JMP exit
S7:
   ADD [SSCORE7],1  
   JMP exit
S8:
   ADD [SSCORE8],1  
   JMP exit
S9:
   ADD [SSCORE9],1
   JMP exit
S10:
   ADD [SSCORE10],1 
   MOV AH,1
   INT 21H

exit:POP AX
   RET  
COMPARE ENDP


OUTPUT PROC  

   LEA DX,SCORE6     
   MOV AH,9
   INT 21H 

   MOV DL,[SSCORE6]
   MOV AH,2

   INT 21H              
   MOV DL,10
   INT 21H  

   ;以下均同上
   LEA DX,SCORE7
   MOV AH,9
   INT 21H   
   MOV DL,[SSCORE7]
   MOV AH,2
   INT 21H  
   MOV DL,10
   INT 21H     

   LEA DX,SCORE8
   MOV AH,9
   INT 21H   
   MOV DL,[SSCORE8]
   MOV AH,2
   INT 21H 
   MOV DL,10
   INT 21H    

   LEA DX,SCORE9
   MOV AH,9
   INT 21H  
   MOV DL,[SSCORE9]
   MOV AH,2
   INT 21H  
   MOV DL,10
   INT 21H   

   LEA DX,SCORE10
   MOV AH,9
   INT 21H  
   MOV DL,[SSCORE10]
   MOV AH,2
   INT 21H  
   MOV DL,10
   INT 21H    

   LEA DX,SCOREOUT
   MOV AH,9
   INT 21H   
   MOV DL,[OUTSCORE]
   MOV AH,2
   INT 21H  
RET     
OUTPUT ENDP 
CODES ENDS
   END START